# Keil uVision project TSUM_New.uvproj, settings and files
target TSUMXXC_DEMO (MCS-51)
  device: 8xC51RD+ Philips
  cpu: IRAM(0 - 0xFF) IROM(0-0xFFFF) XRAM(0 - 0x2FF) CLOCK(33000000) MODP2
  output: TSUM +hex
  AfterMake: 512KMerge.bat TSUMXXC_DEMO.bin
  c flags: Optimize=9 SizeSpeed=1
  c define: ModelName=TSUMXXC_DEMO
  c include: ..\KERNEL\SYSTEM\INC;..\KERNEL\SCALER\INC;..\EXTDEVICE\INC;..\LIB\INC;..\PANEL\INC;..\UI\BOARD;..\UI\INC;..\UI\MODEL;..\DRIVER\INC
  group source
    ../kernel/Scaler/: ms_rwreg.c
    ../kernel/System/: isr.c Common.c
    ../LIB/: CompFont_TSUM2.LIB CompFontTSUMV.LIB CompFont.LIB
    ./: L51_MST_4BANK.A51 STARTUP_TSUMXXV.A51 STARTUP_TSUMXXU.A51 STARTUP_TSUM2.A51 STARTUP_TSUMC.A51 STARTUP_TSUMD.A51 STARTUP_TSUMK.A51 L51_MST_8BANK.A51
  group Bank0
    ../UI/: menu.c msOSD.c MenuStr.c
    ../KERNEL/SCALER/: LoadPropFont1218.c
  group Bank1
    ../kernel/Scaler/: mStar.c AutoFunc.c detect.c MsDLC.c
    ../KERNEL/SCALER/: ms2DTo3D.c drvOSD.c
    ../UI/: MenuStrProp.c MenuFunc.c MenuStrFunc.c
    ../LIB/: msACE_TSUMV.LIB msACE_TSUMC.LIB msACE_TSUMU.LIB msACE_TSUM.LIB msACE_TSUME.LIB
    ../DRIVER/: drvAdjust.c drvMcu.c msScaler.c drvGPIO.c
    ../kernel/System/: Global.c main.c mcu.c mode.c misc.c NVRam.c UserPref.c
  group Bank2
    ../kernel/System/: power.c DDC2Bi.c i2c.c
    ../kernel/Scaler/: Adjust.c DDC.c
    ../UI/: ColorPalette.c FactoryAlignApp.c FactoryAlignAOC.c LoadCommonFont.c
    ../DRIVER/: drvDDC2Bi.c
    ../EXTDEVICE/: TouchPanel.c TouchKey.c
    ../LIB/: msEread_TSUMC.LIB ComboRx.LIB msEread_TSUM9.LIB
    ../KERNEL/SYSTEM/: DDCColorHandler.c
    ../KERNEL/SCALER/: AutoGamma.c
  group Bank3
    ../DRIVER/: appmStar.c drvmStar.c msFB.c
  group Bank4
    ../KERNEL/SCALER/: drvADC.c LedControl.c msOVD.c
    ../DRIVER/: drvmsOVD.c drvDAC.c
    ../kernel/Scaler/: Ms_PM.c
    ../kernel/System/: Debug.c
  group Bank5
    ../DRIVER/: drvGamma.c ms3DLUT.c drvCEC.c
    ../kernel/Scaler/: Gamma.c
    ../KERNEL/SYSTEM/: COLOR_VERIFY.c
    ../KERNEL/SCALER/: msDPS_Handler.c msDPS_Setting.c msDSC_Handler.c msDSC_Setting.c apiCEC.c
    ../DRIVER/USBHost_New/source/: drvhidcore.c drvHost200.c drvHostLib.c drvUsbMain.c drvintpipe.c
    ../DRIVER/USBHost_New/lib/: drvUsbHostLib.c
    ../DRIVER/USBHost_New/source2/: drvhidcore_2.c drvHost200_2.c drvHostLib_2.c drvUsbMain_2.c drvintpipe_2.c
  group Bank6
    ../EXTDEVICE/: USB.c
    ../UI/: Keypad.c
    ../DRIVER/: drv_msHDMI.c drvMHL.c drvDPRxApp.c
    ../kernel/Scaler/: msHDMI.c MsHDCP.c
    ../KERNEL/SCALER/: DPTxApp.c
  group Bank7
    ../KERNEL/SCALER/: UserDataSpace.C ComboApp.c
    ../kernel/System/: MsFlash.c
target TSUMXXC_DEMO_64Bit (MCS-51)
  device: 8xC51RD+ NXP
  cpu: IRAM(0-0xFF) IROM(0-0xFFFF) XRAM(0-0x2FF) CLOCK(33000000) MODP2
  output: TSUM +hex
  BeforeMake: GetTime.bat
  BeforeMake: del.bat
  AfterMake: 512KMerge_64Bit.bat TSUM CD58V00C00B05
  c flags: Optimize=9 SizeSpeed=1
  c define: ModelName=TSUMXXC_DEMO
  c include: ..\KERNEL\SYSTEM\INC;..\KERNEL\SCALER\INC;..\EXTDEVICE\INC;..\LIB\INC;..\PANEL\INC;..\UI\BOARD;..\UI\INC;..\UI\MODEL;..\DRIVER\INC;..\Customer
target TSUMXXF_DEMO (MCS-51)
  device: 8xC51RD+ Philips
  cpu: as above
  output: TSUM +hex
  AfterMake: 512KMerge.bat TSUMXXF_DEMO.bin
  c flags: Optimize=9 SizeSpeed=1
  c define: ModelName=TSUMXXF_DEMO
  c include: ..\KERNEL\SYSTEM\INC;..\KERNEL\SCALER\INC;..\DRIVER\extDEVICE\INC;..\LIB\INC;..\PANEL\INC;..\UI\BOARD;..\UI\INC;..\UI\MODEL;..\DRIVER\INC
target TSUMXXF_DEMO_64Bit (MCS-51)
  device: 8xC51RD+ Philips
  cpu: as above
  output: TSUM +hex
  AfterMake: 512KMerge_64Bit.bat TSUM TSUMXXF_DEMO.bin
  c flags: Optimize=9 SizeSpeed=1
  c define: ModelName=TSUMXXF_DEMO
  c include: ..\KERNEL\SYSTEM\INC;..\KERNEL\SCALER\INC;..\DRIVER\extDEVICE\INC;..\LIB\INC;..\PANEL\INC;..\UI\BOARD;..\UI\INC;..\UI\MODEL;..\DRIVER\INC;..\Customer
target TSUMXX9_DEMO_64Bit (MCS-51)
  device: 8xC51RD+ NXP
  cpu: as above
  output: TSUM +hex
  BeforeMake: GetTime.bat
  BeforeMake: del.bat
  AfterMake: 512KMerge_64Bit.bat TSUM HG588V00C00A05
  c flags: Optimize=9 SizeSpeed=1
  c define: ModelName=TSUMXX9_DEMO
  c include: as above
